## src/Kconfig
```kconfig
config APP_HELLO
    bool "CAmkES application: hello"
    default n
    help
        CAmkES application: hello
```
